## boards/shields/chainoscpad/Kconfig.defconfig
```kconfig
if SHIELD_CHAINOSCPAD

config ZMK_KEYBOARD_NAME
    default "ChainOSCPad"

endif
```
